FILESEXTRAPATHS:prepend:evb-2u-egs := "${THISDIR}/${PN}:"
